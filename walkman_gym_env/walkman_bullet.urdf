Commit message: Update URDF

File: walkman_gym_env/walkman_bullet.urdf (robot description, URDF)
Before this commit: robot walkman, 36 links, 35 joints
Links:
- removed link gaze
Joints:
- removed joint gaze_joint
